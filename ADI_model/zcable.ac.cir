*ac sim command for cable impedance measurement
.include cable.p
iac p0000 n0000 0 AC 1
.ac dec 20 1 10G
