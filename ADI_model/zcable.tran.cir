*tranient sim command for cable impedance measurement
.include cable.p
**************************
***** PD ATTACHMENTS *****
**************************
Xseg0003_0000 p0003 n0003 p0003_0001 n0003_0001 0 tlump
Xseg0003_0001 p0003_0001 n0003_0001 p0003_0002 n0003_0002 0 tlump
Xseg0003_0002 p0003_0002 n0003_0002 p0003_0003 n0003_0003 0 tlump
Xseg0003_0003 p0003_0003 n0003_0003 p0003_0004 n0003_0004 0 tlump
Xseg0003_0004 p0003_0004 n0003_0004 p0003_0005 n0003_0005 0 tlump
Xseg0003_0005 p0003_0005 n0003_0005 p0003_0006 n0003_0006 0 tlump
rpdp0003 p0003_0006 pdp_0001 0.010
rpdn0003 n0003_0006 pdn_0001 0.010
xpd0001 pdp_0001 pdn_0001 0 pd
Xseg0455_0000 p0455 n0455 p0455_0001 n0455_0001 0 tlump
Xseg0455_0001 p0455_0001 n0455_0001 p0455_0002 n0455_0002 0 tlump
Xseg0455_0002 p0455_0002 n0455_0002 p0455_0003 n0455_0003 0 tlump
Xseg0455_0003 p0455_0003 n0455_0003 p0455_0004 n0455_0004 0 tlump
Xseg0455_0004 p0455_0004 n0455_0004 p0455_0005 n0455_0005 0 tlump
Xseg0455_0005 p0455_0005 n0455_0005 p0455_0006 n0455_0006 0 tlump
rpdp0455 p0455_0006 pdp_0002 0.010
rpdn0455 n0455_0006 pdn_0002 0.010
xpd0002 pdp_0002 pdn_0002 0 pd
Xseg0458_0000 p0458 n0458 p0458_0001 n0458_0001 0 tlump
Xseg0458_0001 p0458_0001 n0458_0001 p0458_0002 n0458_0002 0 tlump
Xseg0458_0002 p0458_0002 n0458_0002 p0458_0003 n0458_0003 0 tlump
Xseg0458_0003 p0458_0003 n0458_0003 p0458_0004 n0458_0004 0 tlump
Xseg0458_0004 p0458_0004 n0458_0004 p0458_0005 n0458_0005 0 tlump
Xseg0458_0005 p0458_0005 n0458_0005 p0458_0006 n0458_0006 0 tlump
rpdp0458 p0458_0006 pdp_0003 0.010
rpdn0458 n0458_0006 pdn_0003 0.010
xpd0003 pdp_0003 pdn_0003 0 pd
Xseg0461_0000 p0461 n0461 p0461_0001 n0461_0001 0 tlump
Xseg0461_0001 p0461_0001 n0461_0001 p0461_0002 n0461_0002 0 tlump
Xseg0461_0002 p0461_0002 n0461_0002 p0461_0003 n0461_0003 0 tlump
Xseg0461_0003 p0461_0003 n0461_0003 p0461_0004 n0461_0004 0 tlump
Xseg0461_0004 p0461_0004 n0461_0004 p0461_0005 n0461_0005 0 tlump
Xseg0461_0005 p0461_0005 n0461_0005 p0461_0006 n0461_0006 0 tlump
rpdp0461 p0461_0006 pdp_0004 0.010
rpdn0461 n0461_0006 pdn_0004 0.010
xpd0004 pdp_0004 pdn_0004 0 pd
Xseg0464_0000 p0464 n0464 p0464_0001 n0464_0001 0 tlump
Xseg0464_0001 p0464_0001 n0464_0001 p0464_0002 n0464_0002 0 tlump
Xseg0464_0002 p0464_0002 n0464_0002 p0464_0003 n0464_0003 0 tlump
Xseg0464_0003 p0464_0003 n0464_0003 p0464_0004 n0464_0004 0 tlump
Xseg0464_0004 p0464_0004 n0464_0004 p0464_0005 n0464_0005 0 tlump
Xseg0464_0005 p0464_0005 n0464_0005 p0464_0006 n0464_0006 0 tlump
rpdp0464 p0464_0006 pdp_0005 0.010
rpdn0464 n0464_0006 pdn_0005 0.010
xpd0005 pdp_0005 pdn_0005 0 pd
Xseg0467_0000 p0467 n0467 p0467_0001 n0467_0001 0 tlump
Xseg0467_0001 p0467_0001 n0467_0001 p0467_0002 n0467_0002 0 tlump
Xseg0467_0002 p0467_0002 n0467_0002 p0467_0003 n0467_0003 0 tlump
Xseg0467_0003 p0467_0003 n0467_0003 p0467_0004 n0467_0004 0 tlump
Xseg0467_0004 p0467_0004 n0467_0004 p0467_0005 n0467_0005 0 tlump
Xseg0467_0005 p0467_0005 n0467_0005 p0467_0006 n0467_0006 0 tlump
rpdp0467 p0467_0006 pdp_0006 0.010
rpdn0467 n0467_0006 pdn_0006 0.010
xpd0006 pdp_0006 pdn_0006 0 pd
Xseg0470_0000 p0470 n0470 p0470_0001 n0470_0001 0 tlump
Xseg0470_0001 p0470_0001 n0470_0001 p0470_0002 n0470_0002 0 tlump
Xseg0470_0002 p0470_0002 n0470_0002 p0470_0003 n0470_0003 0 tlump
Xseg0470_0003 p0470_0003 n0470_0003 p0470_0004 n0470_0004 0 tlump
Xseg0470_0004 p0470_0004 n0470_0004 p0470_0005 n0470_0005 0 tlump
Xseg0470_0005 p0470_0005 n0470_0005 p0470_0006 n0470_0006 0 tlump
rpdp0470 p0470_0006 pdp_0007 0.010
rpdn0470 n0470_0006 pdn_0007 0.010
xpd0007 pdp_0007 pdn_0007 0 pd
Xseg0473_0000 p0473 n0473 p0473_0001 n0473_0001 0 tlump
Xseg0473_0001 p0473_0001 n0473_0001 p0473_0002 n0473_0002 0 tlump
Xseg0473_0002 p0473_0002 n0473_0002 p0473_0003 n0473_0003 0 tlump
Xseg0473_0003 p0473_0003 n0473_0003 p0473_0004 n0473_0004 0 tlump
Xseg0473_0004 p0473_0004 n0473_0004 p0473_0005 n0473_0005 0 tlump
Xseg0473_0005 p0473_0005 n0473_0005 p0473_0006 n0473_0006 0 tlump
rpdp0473 p0473_0006 pdp_0008 0.010
rpdn0473 n0473_0006 pdn_0008 0.010
xpd0008 pdp_0008 pdn_0008 0 pd
Xseg0476_0000 p0476 n0476 p0476_0001 n0476_0001 0 tlump
Xseg0476_0001 p0476_0001 n0476_0001 p0476_0002 n0476_0002 0 tlump
Xseg0476_0002 p0476_0002 n0476_0002 p0476_0003 n0476_0003 0 tlump
Xseg0476_0003 p0476_0003 n0476_0003 p0476_0004 n0476_0004 0 tlump
Xseg0476_0004 p0476_0004 n0476_0004 p0476_0005 n0476_0005 0 tlump
Xseg0476_0005 p0476_0005 n0476_0005 p0476_0006 n0476_0006 0 tlump
rpdp0476 p0476_0006 pdp_0009 0.010
rpdn0476 n0476_0006 pdn_0009 0.010
xpd0009 pdp_0009 pdn_0009 0 pd
Xseg0479_0000 p0479 n0479 p0479_0001 n0479_0001 0 tlump
Xseg0479_0001 p0479_0001 n0479_0001 p0479_0002 n0479_0002 0 tlump
Xseg0479_0002 p0479_0002 n0479_0002 p0479_0003 n0479_0003 0 tlump
Xseg0479_0003 p0479_0003 n0479_0003 p0479_0004 n0479_0004 0 tlump
Xseg0479_0004 p0479_0004 n0479_0004 p0479_0005 n0479_0005 0 tlump
Xseg0479_0005 p0479_0005 n0479_0005 p0479_0006 n0479_0006 0 tlump
rpdp0479 p0479_0006 pdp_0010 0.010
rpdn0479 n0479_0006 pdn_0010 0.010
xpd0010 pdp_0010 pdn_0010 0 pd
Xseg0481_0000 p0481 n0481 p0481_0001 n0481_0001 0 tlump
Xseg0481_0001 p0481_0001 n0481_0001 p0481_0002 n0481_0002 0 tlump
Xseg0481_0002 p0481_0002 n0481_0002 p0481_0003 n0481_0003 0 tlump
Xseg0481_0003 p0481_0003 n0481_0003 p0481_0004 n0481_0004 0 tlump
Xseg0481_0004 p0481_0004 n0481_0004 p0481_0005 n0481_0005 0 tlump
Xseg0481_0005 p0481_0005 n0481_0005 p0481_0006 n0481_0006 0 tlump
rpdp0481 p0481_0006 pdp_0011 0.010
rpdn0481 n0481_0006 pdn_0011 0.010
xpd0011 pdp_0011 pdn_0011 0 pd
Xseg0484_0000 p0484 n0484 p0484_0001 n0484_0001 0 tlump
Xseg0484_0001 p0484_0001 n0484_0001 p0484_0002 n0484_0002 0 tlump
Xseg0484_0002 p0484_0002 n0484_0002 p0484_0003 n0484_0003 0 tlump
Xseg0484_0003 p0484_0003 n0484_0003 p0484_0004 n0484_0004 0 tlump
Xseg0484_0004 p0484_0004 n0484_0004 p0484_0005 n0484_0005 0 tlump
Xseg0484_0005 p0484_0005 n0484_0005 p0484_0006 n0484_0006 0 tlump
rpdp0484 p0484_0006 pdp_0012 0.010
rpdn0484 n0484_0006 pdn_0012 0.010
xpd0012 pdp_0012 pdn_0012 0 pd
Xseg0487_0000 p0487 n0487 p0487_0001 n0487_0001 0 tlump
Xseg0487_0001 p0487_0001 n0487_0001 p0487_0002 n0487_0002 0 tlump
Xseg0487_0002 p0487_0002 n0487_0002 p0487_0003 n0487_0003 0 tlump
Xseg0487_0003 p0487_0003 n0487_0003 p0487_0004 n0487_0004 0 tlump
Xseg0487_0004 p0487_0004 n0487_0004 p0487_0005 n0487_0005 0 tlump
Xseg0487_0005 p0487_0005 n0487_0005 p0487_0006 n0487_0006 0 tlump
rpdp0487 p0487_0006 pdp_0013 0.010
rpdn0487 n0487_0006 pdn_0013 0.010
xpd0013 pdp_0013 pdn_0013 0 pd
Xseg0490_0000 p0490 n0490 p0490_0001 n0490_0001 0 tlump
Xseg0490_0001 p0490_0001 n0490_0001 p0490_0002 n0490_0002 0 tlump
Xseg0490_0002 p0490_0002 n0490_0002 p0490_0003 n0490_0003 0 tlump
Xseg0490_0003 p0490_0003 n0490_0003 p0490_0004 n0490_0004 0 tlump
Xseg0490_0004 p0490_0004 n0490_0004 p0490_0005 n0490_0005 0 tlump
Xseg0490_0005 p0490_0005 n0490_0005 p0490_0006 n0490_0006 0 tlump
rpdp0490 p0490_0006 pdp_0014 0.010
rpdn0490 n0490_0006 pdn_0014 0.010
xpd0014 pdp_0014 pdn_0014 0 pd
Xseg0493_0000 p0493 n0493 p0493_0001 n0493_0001 0 tlump
Xseg0493_0001 p0493_0001 n0493_0001 p0493_0002 n0493_0002 0 tlump
Xseg0493_0002 p0493_0002 n0493_0002 p0493_0003 n0493_0003 0 tlump
Xseg0493_0003 p0493_0003 n0493_0003 p0493_0004 n0493_0004 0 tlump
Xseg0493_0004 p0493_0004 n0493_0004 p0493_0005 n0493_0005 0 tlump
Xseg0493_0005 p0493_0005 n0493_0005 p0493_0006 n0493_0006 0 tlump
rpdp0493 p0493_0006 pdp_0015 0.010
rpdn0493 n0493_0006 pdn_0015 0.010
xpd0015 pdp_0015 pdn_0015 0 pd
Xseg0496_0000 p0496 n0496 p0496_0001 n0496_0001 0 tlump
Xseg0496_0001 p0496_0001 n0496_0001 p0496_0002 n0496_0002 0 tlump
Xseg0496_0002 p0496_0002 n0496_0002 p0496_0003 n0496_0003 0 tlump
Xseg0496_0003 p0496_0003 n0496_0003 p0496_0004 n0496_0004 0 tlump
Xseg0496_0004 p0496_0004 n0496_0004 p0496_0005 n0496_0005 0 tlump
Xseg0496_0005 p0496_0005 n0496_0005 p0496_0006 n0496_0006 0 tlump
rpdp0496 p0496_0006 pdp_0016 0.010
rpdn0496 n0496_0006 pdn_0016 0.010
xpd0016 pdp_0016 pdn_0016 0 pd
Xseg0499_0000 p0499 n0499 p0499_0001 n0499_0001 0 tlump
Xseg0499_0001 p0499_0001 n0499_0001 p0499_0002 n0499_0002 0 tlump
Xseg0499_0002 p0499_0002 n0499_0002 p0499_0003 n0499_0003 0 tlump
Xseg0499_0003 p0499_0003 n0499_0003 p0499_0004 n0499_0004 0 tlump
Xseg0499_0004 p0499_0004 n0499_0004 p0499_0005 n0499_0005 0 tlump
Xseg0499_0005 p0499_0005 n0499_0005 p0499_0006 n0499_0006 0 tlump
rpdp0499 p0499_0006 pdp_0017 0.010
rpdn0499 n0499_0006 pdn_0017 0.010
xpd0017 pdp_0017 pdn_0017 0 pd
vap ap 0 0
+pwl 0 0
++50n  0.0
++10n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++10n  0.0
van 0 an 0
+pwl 0 0
++50n  0.0
++10n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n -1.0
++20n  1.0
++20n  1.0
++10n  0.0
rap ap p0000 50
ran an n0000 50
rrefp ap refp 50
rrefn an refn 50
rref  refp refn 100
.save V(*)
.tran 2000n
