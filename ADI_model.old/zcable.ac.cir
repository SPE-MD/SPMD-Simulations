*ac sim command for cable impedance measurement
.include cable.p
vac p0000_p n0000_n 0 AC 1
rp p0000 p0000_p 50
rn n0000_n n0000 50
rrpp p0000_p refp 50
rrpn refp 0 50
rrnp n0000_n refn 50
rrnn refn 0 50
.ac lin 500 1meg 100meg
.net I(rend_term) vac
.save
+ v(refp) v(refn)
+ I(vac) I(rp) I(rend_term)
+ v(p0000) v(n0000)
+ S11(vac) S21(vac)
+ v(p1000) v(n1000)
